<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <!-- Automatically generated by Silicon Labs. -->
    <batchBuild />
    <project>
        <path>$WS_DIR$\connect_bt_dmp_soc_light_cmsisos.ewp</path>
    </project>
</workspace>
