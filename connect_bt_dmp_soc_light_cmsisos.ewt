<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Default</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>516</archiveVersion>
            <data>
                <version>516</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>10</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                    <outputDir>Default/C-STAT</outputDir>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>2.4.0</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="false" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-ARR">
                                <check name="CERT-ARR30-C_a" enabled="true" />
                                <check name="CERT-ARR30-C_b" enabled="true" />
                                <check name="CERT-ARR30-C_c" enabled="true" />
                                <check name="CERT-ARR30-C_d" enabled="true" />
                                <check name="CERT-ARR30-C_e" enabled="true" />
                                <check name="CERT-ARR30-C_f" enabled="true" />
                                <check name="CERT-ARR30-C_g" enabled="true" />
                                <check name="CERT-ARR30-C_h" enabled="true" />
                                <check name="CERT-ARR30-C_i" enabled="true" />
                                <check name="CERT-ARR30-C_j" enabled="true" />
                                <check name="CERT-ARR32-C" enabled="true" />
                                <check name="CERT-ARR36-C_a" enabled="true" />
                                <check name="CERT-ARR36-C_b" enabled="true" />
                                <check name="CERT-ARR37-C" enabled="true" />
                                <check name="CERT-ARR38-C_a" enabled="true" />
                                <check name="CERT-ARR38-C_b" enabled="true" />
                                <check name="CERT-ARR38-C_c" enabled="true" />
                                <check name="CERT-ARR38-C_d" enabled="true" />
                                <check name="CERT-ARR38-C_e" enabled="true" />
                                <check name="CERT-ARR38-C_f" enabled="true" />
                                <check name="CERT-ARR39-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-DCL">
                                <check name="CERT-DCL30-C_a" enabled="true" />
                                <check name="CERT-DCL30-C_b" enabled="true" />
                                <check name="CERT-DCL30-C_c" enabled="true" />
                                <check name="CERT-DCL30-C_d" enabled="true" />
                                <check name="CERT-DCL30-C_e" enabled="true" />
                                <check name="CERT-DCL31-C" enabled="true" />
                                <check name="CERT-DCL36-C" enabled="true" />
                                <check name="CERT-DCL37-C_a" enabled="true" />
                                <check name="CERT-DCL37-C_b" enabled="true" />
                                <check name="CERT-DCL37-C_c" enabled="false" />
                                <check name="CERT-DCL38-C" enabled="true" />
                                <check name="CERT-DCL39-C" enabled="true" />
                                <check name="CERT-DCL40-C" enabled="true" />
                                <check name="CERT-DCL41-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-ENV">
                                <check name="CERT-ENV30-C" enabled="true" />
                                <check name="CERT-ENV31-C" enabled="true" />
                                <check name="CERT-ENV32-C" enabled="true" />
                                <check name="CERT-ENV33-C" enabled="true" />
                                <check name="CERT-ENV34-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-ERR">
                                <check name="CERT-ERR30-C_a" enabled="true" />
                                <check name="CERT-ERR30-C_b" enabled="true" />
                                <check name="CERT-ERR30-C_c" enabled="true" />
                                <check name="CERT-ERR30-C_d" enabled="true" />
                                <check name="CERT-ERR32-C" enabled="true" />
                                <check name="CERT-ERR33-C_a" enabled="true" />
                                <check name="CERT-ERR33-C_b" enabled="true" />
                                <check name="CERT-ERR33-C_c" enabled="true" />
                                <check name="CERT-ERR33-C_d" enabled="true" />
                                <check name="CERT-ERR34-C_a" enabled="true" />
                                <check name="CERT-ERR34-C_b" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                                <check name="CERT-EXP30-C_a" enabled="true" />
                                <check name="CERT-EXP30-C_b" enabled="true" />
                                <check name="CERT-EXP32-C" enabled="true" />
                                <check name="CERT-EXP33-C_a" enabled="true" />
                                <check name="CERT-EXP33-C_b" enabled="true" />
                                <check name="CERT-EXP33-C_c" enabled="true" />
                                <check name="CERT-EXP33-C_d" enabled="true" />
                                <check name="CERT-EXP33-C_e" enabled="true" />
                                <check name="CERT-EXP33-C_f" enabled="true" />
                                <check name="CERT-EXP34-C_a" enabled="true" />
                                <check name="CERT-EXP34-C_b" enabled="true" />
                                <check name="CERT-EXP34-C_c" enabled="true" />
                                <check name="CERT-EXP34-C_d" enabled="true" />
                                <check name="CERT-EXP34-C_e" enabled="true" />
                                <check name="CERT-EXP34-C_f" enabled="true" />
                                <check name="CERT-EXP34-C_g" enabled="true" />
                                <check name="CERT-EXP35-C" enabled="true" />
                                <check name="CERT-EXP36-C_a" enabled="true" />
                                <check name="CERT-EXP36-C_b" enabled="true" />
                                <check name="CERT-EXP37-C_a" enabled="true" />
                                <check name="CERT-EXP37-C_b" enabled="true" />
                                <check name="CERT-EXP37-C_c" enabled="true" />
                                <check name="CERT-EXP39-C_a" enabled="true" />
                                <check name="CERT-EXP39-C_b" enabled="true" />
                                <check name="CERT-EXP39-C_c" enabled="true" />
                                <check name="CERT-EXP39-C_d" enabled="true" />
                                <check name="CERT-EXP39-C_e" enabled="true" />
                                <check name="CERT-EXP40-C_a" enabled="true" />
                                <check name="CERT-EXP40-C_b" enabled="true" />
                                <check name="CERT-EXP42-C" enabled="true" />
                                <check name="CERT-EXP43-C_a" enabled="true" />
                                <check name="CERT-EXP43-C_b" enabled="true" />
                                <check name="CERT-EXP43-C_c" enabled="true" />
                                <check name="CERT-EXP43-C_d" enabled="true" />
                                <check name="CERT-EXP44-C" enabled="true" />
                                <check name="CERT-EXP45-C" enabled="true" />
                                <check name="CERT-EXP46-C" enabled="true" />
                                <check name="CERT-EXP47-C_a" enabled="true" />
                                <check name="CERT-EXP47-C_b" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO30-C" enabled="true" />
                                <check name="CERT-FIO32-C" enabled="true" />
                                <check name="CERT-FIO34-C" enabled="true" />
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                                <check name="CERT-FIO39-C" enabled="true" />
                                <check name="CERT-FIO40-C" enabled="true" />
                                <check name="CERT-FIO41-C" enabled="true" />
                                <check name="CERT-FIO42-C_a" enabled="true" />
                                <check name="CERT-FIO42-C_b" enabled="false" />
                                <check name="CERT-FIO44-C" enabled="true" />
                                <check name="CERT-FIO45-C" enabled="true" />
                                <check name="CERT-FIO46-C_a" enabled="true" />
                                <check name="CERT-FIO46-C_b" enabled="true" />
                                <check name="CERT-FIO46-C_c" enabled="true" />
                                <check name="CERT-FIO47-C_a" enabled="true" />
                                <check name="CERT-FIO47-C_b" enabled="true" />
                                <check name="CERT-FIO47-C_c" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FLP">
                                <check name="CERT-FLP30-C_a" enabled="true" />
                                <check name="CERT-FLP30-C_b" enabled="true" />
                                <check name="CERT-FLP32-C_a" enabled="true" />
                                <check name="CERT-FLP32-C_b" enabled="true" />
                                <check name="CERT-FLP34-C" enabled="true" />
                                <check name="CERT-FLP36-C" enabled="true" />
                                <check name="CERT-FLP37-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-INT">
                                <check name="CERT-INT30-C_a" enabled="true" />
                                <check name="CERT-INT30-C_b" enabled="false" />
                                <check name="CERT-INT31-C_a" enabled="true" />
                                <check name="CERT-INT31-C_b" enabled="true" />
                                <check name="CERT-INT31-C_c" enabled="true" />
                                <check name="CERT-INT32-C_a" enabled="true" />
                                <check name="CERT-INT32-C_b" enabled="false" />
                                <check name="CERT-INT33-C_a" enabled="true" />
                                <check name="CERT-INT33-C_b" enabled="true" />
                                <check name="CERT-INT33-C_c" enabled="true" />
                                <check name="CERT-INT33-C_d" enabled="true" />
                                <check name="CERT-INT33-C_e" enabled="true" />
                                <check name="CERT-INT33-C_f" enabled="true" />
                                <check name="CERT-INT33-C_g" enabled="true" />
                                <check name="CERT-INT33-C_h" enabled="true" />
                                <check name="CERT-INT33-C_i" enabled="true" />
                                <check name="CERT-INT34-C_a" enabled="true" />
                                <check name="CERT-INT34-C_b" enabled="true" />
                                <check name="CERT-INT34-C_c" enabled="true" />
                                <check name="CERT-INT35-C" enabled="true" />
                                <check name="CERT-INT36-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-MEM">
                                <check name="CERT-MEM30-C_a" enabled="true" />
                                <check name="CERT-MEM30-C_b" enabled="true" />
                                <check name="CERT-MEM30-C_c" enabled="true" />
                                <check name="CERT-MEM31-C" enabled="true" />
                                <check name="CERT-MEM33-C_a" enabled="true" />
                                <check name="CERT-MEM33-C_b" enabled="true" />
                                <check name="CERT-MEM34-C_a" enabled="true" />
                                <check name="CERT-MEM34-C_b" enabled="true" />
                                <check name="CERT-MEM34-C_c" enabled="true" />
                                <check name="CERT-MEM35-C_a" enabled="true" />
                                <check name="CERT-MEM35-C_b" enabled="true" />
                                <check name="CERT-MEM35-C_c" enabled="true" />
                                <check name="CERT-MEM36-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-MSC">
                                <check name="CERT-MSC30-C" enabled="true" />
                                <check name="CERT-MSC32-C" enabled="true" />
                                <check name="CERT-MSC33-C" enabled="false" />
                                <check name="CERT-MSC37-C" enabled="true" />
                                <check name="CERT-MSC38-C" enabled="true" />
                                <check name="CERT-MSC39-C" enabled="true" />
                                <check name="CERT-MSC40-C_a" enabled="true" />
                                <check name="CERT-MSC40-C_b" enabled="true" />
                                <check name="CERT-MSC40-C_c" enabled="true" />
                                <check name="CERT-MSC40-C_d" enabled="true" />
                                <check name="CERT-MSC40-C_e" enabled="false" />
                                <check name="CERT-MSC41-C_a" enabled="true" />
                                <check name="CERT-MSC41-C_b" enabled="true" />
                                <check name="CERT-MSC41-C_c" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-PRE">
                                <check name="CERT-PRE31-C" enabled="true" />
                                <check name="CERT-PRE32-C_a" enabled="true" />
                                <check name="CERT-PRE32-C_b" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG30-C" enabled="true" />
                                <check name="CERT-SIG31-C" enabled="true" />
                                <check name="CERT-SIG34-C" enabled="true" />
                                <check name="CERT-SIG35-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-STR">
                                <check name="CERT-STR30-C" enabled="true" />
                                <check name="CERT-STR31-C_a" enabled="true" />
                                <check name="CERT-STR31-C_b" enabled="true" />
                                <check name="CERT-STR31-C_c" enabled="true" />
                                <check name="CERT-STR31-C_d" enabled="true" />
                                <check name="CERT-STR31-C_e" enabled="true" />
                                <check name="CERT-STR31-C_f" enabled="true" />
                                <check name="CERT-STR31-C_g" enabled="true" />
                                <check name="CERT-STR31-C_h" enabled="true" />
                                <check name="CERT-STR32-C" enabled="true" />
                                <check name="CERT-STR34-C" enabled="true" />
                                <check name="CERT-STR37-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.1" enabled="true" />
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.10" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="true" />
                                <check name="MISRAC2012-Dir-4.12" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.14_a" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_h" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_i" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_j" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_l" enabled="true" />
                                <check name="MISRAC2012-Dir-4.14_m" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                                <check name="MISRAC2012-Rule-1.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                                <check name="MISRAC2012-Rule-12.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-20.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                                <check name="MISRAC2012-Rule-21.13" enabled="true" />
                                <check name="MISRAC2012-Rule-21.14" enabled="true" />
                                <check name="MISRAC2012-Rule-21.15" enabled="true" />
                                <check name="MISRAC2012-Rule-21.16" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_a" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_b" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_c" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_d" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_e" enabled="true" />
                                <check name="MISRAC2012-Rule-21.17_f" enabled="true" />
                                <check name="MISRAC2012-Rule-21.18_a" enabled="true" />
                                <check name="MISRAC2012-Rule-21.18_b" enabled="true" />
                                <check name="MISRAC2012-Rule-21.19_a" enabled="true" />
                                <check name="MISRAC2012-Rule-21.19_b" enabled="true" />
                                <check name="MISRAC2012-Rule-21.20" enabled="true" />
                                <check name="MISRAC2012-Rule-21.21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                                <check name="MISRAC2012-Rule-22.7_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.7_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.8" enabled="true" />
                                <check name="MISRAC2012-Rule-22.9" enabled="true" />
                                <check name="MISRAC2012-Rule-22.10" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-5" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>Simplicity Configurator</name>
        <group>
            <name>autogen</name>
            <file>
                <name>$PROJ_DIR$\autogen\.crc_config.crc</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\app_framework_event_table.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\callback_dispatcher.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\callback_dispatcher.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\gatt_db.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\gatt_db.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\linkerfile.icf</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\radioconf_generation_log.json</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\rail_config.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\rail_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\RTE_Components.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_bluetooth.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_bluetooth.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_cli_command_table.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_cli_command_table.html</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_cli_handles.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_cli_instances.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_cli_instances.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_component_catalog.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_device_init_clocks.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_event_handler.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_event_handler.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_iostream_handles.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_iostream_handles.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_iostream_init_eusart_instances.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_iostream_init_eusart_instances.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_iostream_init_instances.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_simple_led_instances.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sl_simple_led_instances.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sli_cli_hooks.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sli_mbedtls_config_autogen.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sli_mbedtls_config_transform_autogen.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sli_psa_builtin_config_autogen.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\autogen\sli_psa_config_autogen.h</name>
            </file>
        </group>
        <group>
            <name>config</name>
            <group>
                <name>btconf</name>
                <file>
                    <name>$PROJ_DIR$\config\btconf\gatt_configuration.btconf</name>
                </file>
            </group>
            <group>
                <name>rail</name>
                <file>
                    <name>$PROJ_DIR$\config\rail\profile_connect.restriction</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\config\rail\profile_long_range.restriction</name>
                </file>
            </group>
            <file>
                <name>$PROJ_DIR$\config\app_assert_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\app_log_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\cmsis-rtos-ipc-config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\debug_print_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\dmadrv_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\emlib_core_debug_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\FreeRTOSConfig.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\legacy_hal_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\mac-queue-config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\nvm3_default_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\poll-config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\psa_crypto_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_bluetooth_advertiser_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_bluetooth_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_bluetooth_connection_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_bt_rtos_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_cli_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_cli_config_example.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_custom_manufacturing_token_header.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_custom_token_header.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_device_init_dcdc_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_device_init_emu_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_device_init_hfxo_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_device_init_lfxo_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_hfxo_manager_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_iostream_eusart_inst0_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_legacy_hal_wdog_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_mbedtls_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_mbedtls_device_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_memory_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_mx25_flash_shutdown_usart_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_power_manager_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_rail_util_pa_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_rail_util_power_manager_init_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_rail_util_pti_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_simple_led_led0_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_sleeptimer_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\sl_token_manager_config.h</name>
            </file>
            <file>
                <name>$PROJ_DIR$\config\stack-common-config.h</name>
            </file>
        </group>
        <group>
            <name>gecko_sdk_4.3.1</name>
            <group>
                <name>app</name>
                <group>
                    <name>common</name>
                    <group>
                        <name>util</name>
                        <group>
                            <name>app_assert</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\common\util\app_assert\app_assert.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\common\util\app_assert\sl_app_assert.h</name>
                            </file>
                        </group>
                        <group>
                            <name>app_log</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\common\util\app_log\app_log.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\common\util\app_log\app_log.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\common\util\app_log\sl_app_log.h</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>flex</name>
                    <group>
                        <name>component</name>
                        <group>
                            <name>connect</name>
                            <group>
                                <name>sl_light_switch</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\flex\component\connect\sl_light_switch\sl_light_switch.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\app\flex\component\connect\sl_light_switch\sl_light_switch.h</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
            </group>
            <group>
                <name>hardware</name>
                <group>
                    <name>driver</name>
                    <group>
                        <name>mx25_flash_shutdown</name>
                        <group>
                            <name>inc</name>
                            <group>
                                <name>sl_mx25_flash_shutdown_usart</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_usart\sl_mx25_flash_shutdown.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>src</name>
                            <group>
                                <name>sl_mx25_flash_shutdown_usart</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\hardware\driver\mx25_flash_shutdown\src\sl_mx25_flash_shutdown_usart\sl_mx25_flash_shutdown.c</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
            </group>
            <group>
                <name>platform</name>
                <group>
                    <name>CMSIS</name>
                    <group>
                        <name>Core</name>
                        <group>
                            <name>Include</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\cmsis_compiler.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\cmsis_iccarm.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\cmsis_version.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\core_cm33.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\mpu_armv8.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\Core\Include\tz_context.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>RTOS2</name>
                        <group>
                            <name>Include</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\RTOS2\Include\cmsis_os2.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\RTOS2\Include\os_tick.h</name>
                            </file>
                        </group>
                        <group>
                            <name>Source</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\CMSIS\RTOS2\Source\os_systick.c</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>common</name>
                    <group>
                        <name>inc</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_assert.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_atomic.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_cmsis_os2_common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_enum.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_slist.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_status.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sl_string.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\inc\sli_cmsis_os2_ext_task_register.h</name>
                        </file>
                    </group>
                    <group>
                        <name>src</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\src\sl_assert.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\src\sl_slist.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\src\sl_string.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\src\sli_cmsis_os2_ext_task_register.c</name>
                        </file>
                    </group>
                    <group>
                        <name>toolchain</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\toolchain\inc\sl_memory.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\toolchain\inc\sl_memory_region.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\common\toolchain\src\sl_memory.c</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>Device</name>
                    <group>
                        <name>SiliconLabs</name>
                        <group>
                            <name>EFR32FG28</name>
                            <group>
                                <name>Include</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_acmp.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_aes.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_buram.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_burtc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_cmu.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_dcdc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_devinfo.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_dma_descriptor.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_dpll.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_emu.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_eusart.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_fsrco.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_gpcrc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_gpio.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_gpio_port.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_hfrco.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_hfxo.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_i2c.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_iadc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_icache.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_keyscan.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_lcd.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_lcdrf.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_ldma.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_ldmaxbar.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_ldmaxbar_defines.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_lesense.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_letimer.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_lfrco.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_lfxo.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_mailbox.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_mpahbram.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_msc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_mvp.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_pcnt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_pfmxpprf.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_prs.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_prs_signals.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_scratchpad.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_semailbox.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_smu.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_syscfg.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_sysrtc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_timer.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_ulfrco.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_usart.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_vdac.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28_wdog.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\efr32fg28b322f1024im68.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\em_device.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Include\system_efr32fg28.h</name>
                                </file>
                            </group>
                            <group>
                                <name>Source</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Source\startup_efr32fg28.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\Device\SiliconLabs\EFR32FG28\Source\system_efr32fg28.c</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
                <group>
                    <name>driver</name>
                    <group>
                        <name>leddrv</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\driver\leddrv\inc\sl_led.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\driver\leddrv\inc\sl_simple_led.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\driver\leddrv\src\sl_led.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\driver\leddrv\src\sl_simple_led.c</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>emdrv</name>
                    <group>
                        <name>common</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\common\inc\ecode.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>dmadrv</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\dmadrv\inc\dmadrv.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\dmadrv\src\dmadrv.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>nvm3</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3_default.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3_generic.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3_hal.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3_hal_flash.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\inc\nvm3_lock.h</name>
                            </file>
                        </group>
                        <group>
                            <name>lib</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\lib\libnvm3_CM33_iar.a</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\src\nvm3_default_common_linker.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\src\nvm3_hal_flash.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emdrv\nvm3\src\nvm3_lock.c</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>emlib</name>
                    <group>
                        <name>inc</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_assert.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_burtc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_bus.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_chip.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_cmu.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_cmu_compat.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_core.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_core_generic.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_emu.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_eusart.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_eusart_compat.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_gpio.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_ldma.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_msc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_msc_compat.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_prs.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_ramfunc.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_rmu.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_se.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_syscfg.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_system.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_system_generic.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_timer.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_usart.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_version.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\em_wdog.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\inc\sli_em_cmu.h</name>
                        </file>
                    </group>
                    <group>
                        <name>src</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_burtc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_cmu.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_core.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_emu.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_eusart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_gpio.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_ldma.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_msc.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_prs.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_rmu.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_se.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_system.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_timer.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_usart.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\emlib\src\em_wdog.c</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>peripheral</name>
                    <group>
                        <name>inc</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\peripheral\inc\peripheral_sysrtc.h</name>
                        </file>
                    </group>
                    <group>
                        <name>src</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\peripheral\src\peripheral_sysrtc.c</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>radio</name>
                    <group>
                        <name>rail_lib</name>
                        <group>
                            <name>autogen</name>
                            <group>
                                <name>librail_release</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\autogen\librail_release\librail_multiprotocol_efr32xg28_iar_release.a</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>chip</name>
                            <group>
                                <name>efr32</name>
                                <group>
                                    <name>efr32xg2x</name>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\chip\efr32\efr32xg2x\rail_chip_specific.h</name>
                                    </file>
                                </group>
                            </group>
                        </group>
                        <group>
                            <name>common</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\common\rail.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\common\rail_assert_error_codes.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\common\rail_features.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\common\rail_mfm.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\common\rail_types.h</name>
                            </file>
                        </group>
                        <group>
                            <name>plugin</name>
                            <group>
                                <name>pa-conversions</name>
                                <group>
                                    <name>efr32xg28</name>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28\sl_rail_util_pa_curves_14dbm_868M.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28\sl_rail_util_pa_curves_14dbm_915M.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28\sl_rail_util_pa_curves_20dbm_868M.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28\sl_rail_util_pa_curves_20dbm_915M.h</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\pa_conversions_efr32.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\pa_conversions_efr32.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\pa_curve_types_efr32.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\pa_curves_efr32.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\pa-conversions\pa_curves_efr32.h</name>
                                </file>
                            </group>
                            <group>
                                <name>rail_util_power_manager_init</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\rail_util_power_manager_init\sl_rail_util_power_manager_init.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\rail_util_power_manager_init\sl_rail_util_power_manager_init.h</name>
                                </file>
                            </group>
                            <group>
                                <name>rail_util_pti</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\rail_util_pti\sl_rail_util_pti.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\plugin\rail_util_pti\sl_rail_util_pti.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>protocol</name>
                            <group>
                                <name>ble</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\protocol\ble\rail_ble.h</name>
                                </file>
                            </group>
                            <group>
                                <name>ieee802154</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\protocol\ieee802154\rail_ieee802154.h</name>
                                </file>
                            </group>
                            <group>
                                <name>sidewalk</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\protocol\sidewalk\rail_sidewalk.h</name>
                                </file>
                            </group>
                            <group>
                                <name>wmbus</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\protocol\wmbus\rail_wmbus.h</name>
                                </file>
                            </group>
                            <group>
                                <name>zwave</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\radio\rail_lib\protocol\zwave\rail_zwave.h</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
                <group>
                    <name>security</name>
                    <group>
                        <name>sl_component</name>
                        <group>
                            <name>se_manager</name>
                            <group>
                                <name>inc</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_attestation.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_check_config.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_cipher.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_config.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_defines.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_entropy.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_hash.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_internal_keys.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_key_derivation.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_key_handling.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_signature.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_types.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sl_se_manager_util.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sli_se_manager_features.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\inc\sli_se_manager_internal.h</name>
                                </file>
                            </group>
                            <group>
                                <name>src</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_attestation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_cipher.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_entropy.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_hash.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_key_derivation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_key_handling.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_signature.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sl_se_manager_util.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sli_se_manager_osal.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\se_manager\src\sli_se_manager_osal_cmsis_rtos2.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>sl_mbedtls_support</name>
                            <group>
                                <name>config</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\config\sli_mbedtls_acceleration.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\config\sli_mbedtls_omnipresent.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\config\sli_psa_acceleration.h</name>
                                </file>
                            </group>
                            <group>
                                <name>inc</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\aes_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\ccm_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\cmac_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\ecjpake_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\gcm_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\se_management.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sha1_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sha256_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sha512_alt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sl_mbedtls.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sl_psa_crypto.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sl_psa_values.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\sli_psa_crypto.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\inc\threading_alt.h</name>
                                </file>
                            </group>
                            <group>
                                <name>src</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\src\mbedtls_ccm.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\src\se_aes.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\src\sl_mbedtls.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\src\sl_psa_crypto.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_mbedtls_support\src\sli_psa_crypto.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>sl_protocol_crypto</name>
                            <group>
                                <name>src</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_protocol_crypto\src\sli_protocol_crypto.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_protocol_crypto\src\sli_protocol_crypto_radioaes.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_protocol_crypto\src\sli_radioaes_management.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_protocol_crypto\src\sli_radioaes_management.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>sl_psa_driver</name>
                            <group>
                                <name>inc</name>
                                <group>
                                    <name>psa</name>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\psa\error.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\psa\internal_trusted_storage.h</name>
                                    </file>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\psa\sli_internal_trusted_storage.h</name>
                                    </file>
                                </group>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_psa_driver_common.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_psa_driver_features.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_driver_aead.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_driver_cipher.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_driver_key_derivation.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_driver_key_management.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_driver_mac.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_opaque_functions.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_opaque_types.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_transparent_functions.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_transparent_types.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\inc\sli_se_version_dependencies.h</name>
                                </file>
                            </group>
                            <group>
                                <name>src</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sl_psa_its_nvm3.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_psa_driver_common.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_psa_driver_init.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_psa_trng.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_aead.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_builtin_keys.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_cipher.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_key_derivation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_key_management.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_mac.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_driver_signature.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_opaque_driver_aead.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_opaque_driver_cipher.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_opaque_driver_mac.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_opaque_key_derivation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_transparent_driver_aead.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_transparent_driver_cipher.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_transparent_driver_hash.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_transparent_driver_mac.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_transparent_key_derivation.c</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\security\sl_component\sl_psa_driver\src\sli_se_version_dependencies.c</name>
                                </file>
                            </group>
                        </group>
                    </group>
                </group>
                <group>
                    <name>service</name>
                    <group>
                        <name>cli</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli_arguments.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli_command.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli_input.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli_tokenize.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\inc\sl_cli_types.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli_arguments.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli_command.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli_input.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli_io.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sl_cli_tokenize.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sli_cli_arguments.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sli_cli_input.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\cli\src\sli_cli_io.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>device_init</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_clocks.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_dcdc.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_emu.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_hfxo.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_lfxo.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\inc\sl_device_init_nvic.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\src\sl_device_init_dcdc_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\src\sl_device_init_emu_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\src\sl_device_init_hfxo_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\src\sl_device_init_lfxo_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\device_init\src\sl_device_init_nvic.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>hfxo_manager</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\hfxo_manager\inc\sl_hfxo_manager.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\hfxo_manager\inc\sli_hfxo_manager.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\hfxo_manager\src\sl_hfxo_manager.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\hfxo_manager\src\sl_hfxo_manager_hal_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\hfxo_manager\src\sli_hfxo_manager_internal.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>iostream</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sl_iostream.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sl_iostream_eusart.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sl_iostream_stdlib_config.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sl_iostream_uart.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sl_iostream_usart.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\inc\sli_iostream_uart.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream_eusart.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream_retarget_stdio.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream_stdlib_config.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream_uart.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\iostream\src\sl_iostream_usart.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>legacy_hal</name>
                        <group>
                            <name>inc</name>
                            <group>
                                <name>cortexm3</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\cortexm3\diagnostic.h</name>
                                </file>
                            </group>
                            <group>
                                <name>hal</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\hal\hal.h</name>
                                </file>
                            </group>
                            <group>
                                <name>serial</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\serial\serial.h</name>
                                </file>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\asm.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\bootloader-interface-app.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\bootloader-interface.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\button.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\crc.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\efm32_micro.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\em2xx-reset-defs.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\emlib_config.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\hal.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\interrupts-efm32.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\led.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\micro-common.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\micro-types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\micro.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\platform-header.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\random.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\reset-def.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\serial.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\sl_legacy_hal_integration_hooks.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\token-manufacturing-series-1.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\token-manufacturing-series-2.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\inc\token-manufacturing.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\base-replacement.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\crc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\diagnostic.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\ember-phy.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\faults.s</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\random.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal\src\token_legacy.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>legacy_hal_wdog</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal_wdog\inc\sl_legacy_hal_wdog.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\legacy_hal_wdog\src\sl_legacy_hal_wdog.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>mpu</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\mpu\inc\sl_mpu.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\mpu\src\sl_mpu.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>power_manager</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\inc\sl_power_manager.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\inc\sl_power_manager_debug.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\inc\sli_power_manager.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\src\sl_power_manager.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\src\sl_power_manager_debug.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\src\sl_power_manager_hal_s2.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\power_manager\src\sli_power_manager_private.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>sleeptimer</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\inc\sl_sleeptimer.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\inc\sli_sleeptimer.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\src\sl_sleeptimer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\src\sl_sleeptimer_hal_burtc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\src\sl_sleeptimer_hal_sysrtc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\src\sl_sleeptimer_hal_timer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\sleeptimer\src\sli_sleeptimer_hal.h</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>system</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\system\inc\sl_system_init.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\system\inc\sl_system_kernel.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\system\src\sl_system_init.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\system\src\sl_system_kernel.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>token_manager</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_api.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manager.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manager_af_token_header.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manufacturing.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manufacturing_api.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manufacturing_series_1.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\inc\sl_token_manufacturing_series_2.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\src\sl_token_def.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\src\sl_token_manager.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\token_manager\src\sl_token_manufacturing.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>udelay</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\udelay\inc\sl_udelay.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\udelay\src\sl_udelay.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\platform\service\udelay\src\sl_udelay_armv6m_iar.s</name>
                            </file>
                        </group>
                    </group>
                </group>
            </group>
            <group>
                <name>protocol</name>
                <group>
                    <name>bluetooth</name>
                    <group>
                        <name>api</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\api\sl_bt.xapi</name>
                        </file>
                    </group>
                    <group>
                        <name>bgstack</name>
                        <group>
                            <name>ll</name>
                            <group>
                                <name>inc</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\bgstack\ll\inc\sl_btctrl_linklayer.h</name>
                                </file>
                            </group>
                        </group>
                    </group>
                    <group>
                        <name>inc</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bgapi.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_api.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_api_compatibility.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_ll_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_rtos_adaptation.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_stack_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_stack_init.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_types.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sl_bt_version.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_accept_list_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_advertiser_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_config_defs.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_connection_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_dynamic_gattdb_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_gattdb_def.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_l2cap_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_pawr_advertiser_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_periodic_adv_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_periodic_advertiser_config.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\inc\sli_bt_sync_config.h</name>
                        </file>
                    </group>
                    <group>
                        <name>lib</name>
                        <group>
                            <name>EFR32XG28</name>
                            <group>
                                <name>IAR</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\lib\EFR32XG28\IAR\libbluetooth.a</name>
                                </file>
                            </group>
                        </group>
                    </group>
                    <group>
                        <name>src</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sl_bt_rtos_adaptation.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sl_bt_stack_init.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_accept_list_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_advertiser_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_connection_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_dynamic_gattdb_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_l2cap_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_pawr_advertiser_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_periodic_adv_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_periodic_advertiser_config.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\bluetooth\src\sli_bt_sync_config.c</name>
                        </file>
                    </group>
                </group>
                <group>
                    <name>flex</name>
                    <group>
                        <name>app-framework-common</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_callback.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_common.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_common_cb.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_sleep.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\app-framework-common\app_framework_stack_cb.c</name>
                        </file>
                    </group>
                    <group>
                        <name>ble-cli</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\ble-cli\ble-cli.c</name>
                        </file>
                    </group>
                    <group>
                        <name>cmsis-stack-ipc</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-af-task.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-ipc-common.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-support-gen.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-support.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-support.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\cmsis-rtos-vncp-task.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\cmsis-stack-ipc\os_app_hooks.c</name>
                        </file>
                    </group>
                    <group>
                        <name>csp</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-api-enum-gen.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-command-app.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-command-callbacks.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-command-utils.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-command-vncp.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-common.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-enum.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-format.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\csp\csp-format.h</name>
                        </file>
                    </group>
                    <group>
                        <name>debug-print</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\debug-print\debug_print.h</name>
                        </file>
                    </group>
                    <group>
                        <name>libs</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\libs\libconnect-aes-security-library-efr32xg2x-iar.a</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\libs\libconnect-packet-queue-library-efr32xg2x-iar.a</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\libs\libconnect-stack-common-library-efr32xg2x-iar.a</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\libs\libconnect-stack-counters-library-efr32xg2x-iar.a</name>
                        </file>
                    </group>
                    <group>
                        <name>ncp</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\ncp\ncp-security.h</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\ncp\ncp-stubs.c</name>
                        </file>
                    </group>
                    <group>
                        <name>poll</name>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\poll\poll.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\poll\poll.h</name>
                        </file>
                    </group>
                    <group>
                        <name>stack</name>
                        <group>
                            <name>config</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\config.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\ember-configuration-defaults.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\ember-configuration.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\stack-callback-stubs.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\stack-stubs.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\config\token-stack.h</name>
                            </file>
                        </group>
                        <group>
                            <name>core</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\core\sli-connect-api.h</name>
                            </file>
                        </group>
                        <group>
                            <name>include</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\byte-utilities.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\ember-types.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\ember.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\error-def.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\error.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\event.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\memory-buffer.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\message.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\network-management.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\packet-buffer.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\radio-stream.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\protocol\flex\stack\include\stack-info.h</name>
                            </file>
                        </group>
                    </group>
                </group>
            </group>
            <group>
                <name>util</name>
                <group>
                    <name>silicon_labs</name>
                    <group>
                        <name>silabs_core</name>
                        <group>
                            <name>memory_manager</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\silicon_labs\silabs_core\memory_manager\sl_malloc.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\silicon_labs\silabs_core\memory_manager\sl_malloc.h</name>
                            </file>
                        </group>
                    </group>
                </group>
                <group>
                    <name>third_party</name>
                    <group>
                        <name>freertos</name>
                        <group>
                            <name>cmsis</name>
                            <group>
                                <name>Include</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\cmsis\Include\freertos_mpool.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\cmsis\Include\freertos_os2.h</name>
                                </file>
                            </group>
                            <group>
                                <name>Source</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\cmsis\Source\cmsis_os2.c</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>kernel</name>
                            <group>
                                <name>include</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\atomic.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\croutine.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\deprecated_definitions.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\event_groups.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\FreeRTOS.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\list.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\message_buffer.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\mpu_prototypes.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\mpu_wrappers.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\portable.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\projdefs.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\queue.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\semphr.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\stack_macros.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\StackMacros.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\stream_buffer.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\task.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\include\timers.h</name>
                                </file>
                            </group>
                            <group>
                                <name>portable</name>
                                <group>
                                    <name>IAR</name>
                                    <group>
                                        <name>ARM_CM33_NTZ</name>
                                        <group>
                                            <name>non_secure</name>
                                            <file>
                                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure\port.c</name>
                                            </file>
                                            <file>
                                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure\portasm.h</name>
                                            </file>
                                            <file>
                                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure\portasm.s</name>
                                            </file>
                                            <file>
                                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure\portmacro.h</name>
                                            </file>
                                        </group>
                                    </group>
                                </group>
                                <group>
                                    <name>MemMang</name>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\MemMang\heap_4.c</name>
                                    </file>
                                </group>
                                <group>
                                    <name>SiliconLabs</name>
                                    <file>
                                        <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\portable\SiliconLabs\tick_power_manager.c</name>
                                    </file>
                                </group>
                            </group>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\croutine.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\event_groups.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\list.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\queue.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\stream_buffer.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\tasks.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\freertos\kernel\timers.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>mbedtls</name>
                        <group>
                            <name>include</name>
                            <group>
                                <name>mbedtls</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\aes.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\aria.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\asn1.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\asn1write.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\base64.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\bignum.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\build_info.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\camellia.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ccm.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\chacha20.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\chachapoly.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\check_config.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\cipher.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\cmac.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\compat-2.x.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\config_psa.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\constant_time.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ctr_drbg.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\debug.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\des.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\dhm.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ecdh.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ecdsa.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ecjpake.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ecp.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\entropy.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\error.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\gcm.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\hkdf.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\hmac_drbg.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\mbedtls_config.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\md.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\md5.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\memory_buffer_alloc.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\net_sockets.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\nist_kw.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\oid.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\pem.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\pk.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\pkcs12.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\pkcs5.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\platform.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\platform_time.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\platform_util.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\poly1305.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\private_access.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\psa_util.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ripemd160.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\rsa.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\sha1.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\sha256.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\sha512.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ssl.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ssl_cache.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ssl_ciphersuites.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ssl_cookie.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\ssl_ticket.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\threading.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\timing.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\version.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\x509.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\x509_crl.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\x509_crt.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\mbedtls\x509_csr.h</name>
                                </file>
                            </group>
                            <group>
                                <name>psa</name>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_builtin_composites.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_builtin_primitives.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_compat.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_config.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_driver_common.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_driver_contexts_composites.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_driver_contexts_primitives.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_extra.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_platform.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_se_driver.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_sizes.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_struct.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_types.h</name>
                                </file>
                                <file>
                                    <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\include\psa\crypto_values.h</name>
                                </file>
                            </group>
                        </group>
                        <group>
                            <name>library</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\aes.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\bignum_internal.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\bn_mul.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ccm.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\check_crypto_config.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\cipher.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\cipher_wrap.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\cipher_wrap.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\common.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\constant_time.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\constant_time_internal.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\constant_time_invasive.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ecp_internal_alt.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ecp_invasive.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\entropy_poll.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\md_wrap.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\mps_common.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\mps_error.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\mps_reader.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\mps_trace.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\padlock.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\pk_wrap.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\pkwrite.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\platform.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\platform_util.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_aead.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_aead.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_cipher.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_cipher.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_client.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_core.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_driver_wrappers.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_driver_wrappers.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_ecp.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_ecp.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_hash.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_hash.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_invasive.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_its.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_mac.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_mac.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_random_impl.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_rsa.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_rsa.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_se.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_se.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_slot_management.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_slot_management.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_storage.c</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\psa_crypto_storage.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\rsa_alt_helpers.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ssl_client.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ssl_debug_helpers.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ssl_misc.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ssl_tls13_invasive.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\ssl_tls13_keys.h</name>
                            </file>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\mbedtls\library\threading.c</name>
                            </file>
                        </group>
                    </group>
                    <group>
                        <name>printf</name>
                        <group>
                            <name>inc</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\printf\inc\iostream_printf.h</name>
                            </file>
                        </group>
                        <group>
                            <name>src</name>
                            <file>
                                <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\printf\src\iostream_printf.c</name>
                            </file>
                        </group>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\printf\printf.c</name>
                        </file>
                        <file>
                            <name>$PROJ_DIR$\gecko_sdk_4.3.1\util\third_party\printf\printf.h</name>
                        </file>
                    </group>
                </group>
            </group>
        </group>
        <file>
            <name>$PROJ_DIR$\app_bluetooth.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\app_cli.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\app_init.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\app_init.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\app_process.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\app_process.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\connect_create_gbl_image.bat</name>
        </file>
        <file>
            <name>$PROJ_DIR$\connect_create_gbl_image.sh</name>
        </file>
        <file>
            <name>$PROJ_DIR$\main.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\README.md</name>
        </file>
    </group>
    <file>
        <name>$PROJ_DIR$\connect_bt_dmp_soc_light_cmsisos.ipcf</name>
    </file>
</project>
