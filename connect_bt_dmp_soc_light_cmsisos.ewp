# IAR project connect_bt_dmp_soc_light_cmsisos.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG28B322F1024IM68 SiliconLaboratories EFR32FG28B322F1024IM68
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: SL_CONNECT_DISABLE_WATCHDOG=1; EFR32FG28B322F1024IM68=1; SL_CODE_COMPONENT_SYSTEM=system; SL_APP_PROPERTIES=1; BOOTLOADER_APPLOADER=1; SL_CLOCK_MANAGER_AUTO_BAND_VALID=1; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; configNUM_SDK_THREAD_LOCAL_STORAGE_POINTERS=2; SL_COMPONENT_CATALOG_PRESENT=1; CMSISRTOS=1; SKIP_API_RENAME=1; SL_CONNECT_RTOS_PRESENT=1; EMBER_STACK_CONNECT=1; PLATFORM_HEADER="platform-header.h"; SL_RAIL_3_API=1; STACK_CORE_HEADER="stack/include/ember.h"; STACK_HEADER="stack/include/ember.h"; STACK_TYPES_HEADER="stack/include/ember-types.h"; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_DMADRV=dmadrv; SL_CODE_COMPONENT_FREERTOS_KERNEL=freertos_kernel; SL_CODE_COMPONENT_GPIO=gpio; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_HAL_SYSRTC=hal_sysrtc; SL_CODE_COMPONENT_INTERRUPT_MANAGER=interrupt_manager; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_CODE_COMPONENT_MEMORY_MANAGER=memory_manager; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=1; SL_CODE_COMPONENT_SE_MANAGER=se_manager; SL_CODE_COMPONENT_CORE=core; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SL_RAIL_UTIL_PA_PLUGIN_HEADER=<sl_rail_util_pa_conversions.h>; SL_RAIL_UTIL_PA_TABLES_CONFIG_HEADER=<sl_rail_util_pa_tables_config.h>; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_SLI_CRYPTO=sli_crypto; SLI_RADIOAES_REQUIRES_MASKING=1; SL_CODE_COMPONENT_SLI_PROTOCOL_CRYPTO=sli_protocol_crypto; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; SL_TOKEN_MANAGER_BACKWARD_COMPATIBILITY=1; USE_NVM3=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\rail; config\btconf; .; simplicity_sdk_2025.12.3\devices\platform\Device\SiliconLabs\EFR32FG28\Include; simplicity_sdk_2025.12.3\platform_common_apps\app\common\util\app_assert; simplicity_sdk_2025.12.3\platform_common_apps\app\common\util\app_log; simplicity_sdk_2025.12.3\bluetooth_apploader\inc; simplicity_sdk_2025.12.3\platform_common\platform\common\inc; simplicity_sdk_2025.12.3\bgapi_protocol\protocol\inc; simplicity_sdk_2025.12.3\bgapi_protocol\rtos_adaptation\inc; simplicity_sdk_2025.12.3\bluetooth_common\inc; simplicity_sdk_2025.12.3\bluetooth_le_host\inc; simplicity_sdk_2025.12.3\bluetooth_le_controller\inc; simplicity_sdk_2025.12.3\bootloader_interface\platform\bootloader; simplicity_sdk_2025.12.3\bootloader_interface\platform\bootloader\api; simplicity_sdk_2025.12.3\bootloader_interface\platform\bootloader\core\flash; simplicity_sdk_2025.12.3\platform_core\platform\service\cli\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\cli\src; simplicity_sdk_2025.12.3\platform_core\platform\service\clock_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\clock_manager\src; simplicity_sdk_2025.12.3\cmsis_common\platform\common\inc; simplicity_sdk_2025.12.3\cmsis\Core\Include; simplicity_sdk_2025.12.3\cmsis\RTOS2\Include; simplicity_sdk_2025.12.3\connect_stack\app-framework-common; simplicity_sdk_2025.12.3\connect_stack\cmsis-stack-ipc; simplicity_sdk_2025.12.3\connect_stack\csp; simplicity_sdk_2025.12.3\connect_stack\ncp; simplicity_sdk_2025.12.3\connect_stack\debug-print; simplicity_sdk_2025.12.3\connect_stack\poll; simplicity_sdk_2025.12.3\connect_stack; simplicity_sdk_2025.12.3\connect_stack\stack; simplicity_sdk_2025.12.3\connect_stack\stack\include; simplicity_sdk_2025.12.3\connect_stack\stack\framework; simplicity_sdk_2025.12.3\connect_stack\stack\core; simplicity_sdk_2025.12.3\platform_core\platform\service\device_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\device_init\inc; simplicity_sdk_2025.12.3\platform_core\platform\emdrv\dmadrv\inc; simplicity_sdk_2025.12.3\platform_core\platform\emdrv\dmadrv\inc\s2_signals; simplicity_sdk_2025.12.3\platform_core\platform\emdrv\common\inc; simplicity_sdk_2025.12.3\platform_core\platform\emlib\inc; simplicity_sdk_2025.12.3\platform_core\platform\common\errno_error_codes\inc; simplicity_sdk_2025.12.3\freertos\kernel\include; simplicity_sdk_2025.12.3\freertos\cmsis\Include; simplicity_sdk_2025.12.3\freertos\kernel\portable\IAR\ARM_CM33_NTZ\non_secure; simplicity_sdk_2025.12.3\platform_core\platform\driver\gpio\inc; simplicity_sdk_2025.12.3\platform_core\platform\peripheral\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\hfxo_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\hfxo_manager\src; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\src; simplicity_sdk_2025.12.3\platform_core\platform\service\interrupt_manager\inc\arm; simplicity_sdk_2025.12.3\platform_core\platform\service\iostream\inc; simplicity_sdk_2025.12.3\platform_core\platform\driver\leddrv\inc; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\config; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\config\preset; simplicity_sdk_2025.12.3\security_mbedtls_source\include; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sl_mbedtls_support\inc; simplicity_sdk_2025.12.3\security_mbedtls_source\library; simplicity_sdk_2025.12.3\platform_core\platform\service\memory_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\memory_manager\src; simplicity_sdk_2025.12.3\platform_core\platform\service\memory_manager\profiler\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\mpu\inc; simplicity_sdk_2025.12.3\platform_core\platform\emdrv\nvm3\inc; simplicity_sdk_2025.12.3\platform_core\platform\emdrv\nvm3\config; simplicity_sdk_2025.12.3\platform_core\platform\common\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\power_manager\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\power_manager\src\common; simplicity_sdk_2025.12.3\platform_core\platform\service\power_manager\src\sleep_loop; simplicity_sdk_2025.12.3\printf; simplicity_sdk_2025.12.3\printf\inc; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sl_psa_driver\inc; simplicity_sdk_2025.12.3\rail_library\common; simplicity_sdk_2025.12.3\rail_library\protocol\ble; simplicity_sdk_2025.12.3\rail_library\protocol\ieee802154; simplicity_sdk_2025.12.3\rail_library\protocol\wmbus; simplicity_sdk_2025.12.3\rail_library\protocol\zwave; simplicity_sdk_2025.12.3\rail_library\chip\efr32\efr32xg2x; simplicity_sdk_2025.12.3\rail_library\protocol\sidewalk; simplicity_sdk_2025.12.3\security_se_manager\platform\security\sl_component\se_manager\inc; simplicity_sdk_2025.12.3\common_15_4\util\silicon_labs\silabs_core\buffer_manager; simplicity_sdk_2025.12.3\connect_sdk\component\sl_light_switch; simplicity_sdk_2025.12.3\platform_core\platform\service\sl_main\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\sl_main\src; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_compatible_pa; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_pa_conversions; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_pa_tables; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_pa_tables\efr32xg28; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_power_manager_init; simplicity_sdk_2025.12.3\rail_library\plugin\sl_rail_util_pti; simplicity_sdk_2025.12.3\platform_core\platform\service\sleeptimer\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\sleeptimer\src; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sli_crypto\inc; simplicity_sdk_2025.12.3\security_mbedtls\platform\security\sl_component\sl_protocol_crypto\src; simplicity_sdk_2025.12.3\security_se_manager\platform\security\sl_component\sli_psec_osal\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\token_manager\legacy\inc; simplicity_sdk_2025.12.3\platform_core\platform\service\udelay\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: connect_bt_dmp_soc_light_cmsisos.s37
  ILINK.IlinkOutputFile: connect_bt_dmp_soc_light_cmsisos.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: connect_bt_dmp_soc_light_cmsisos.ipcf
  group custom_code
    custom_code/: aes-wrapper.c aes-wrapper.h rf-test_cli.c rf-test_cli.h
  group Simplicity Configurator
    ./: AGENTS.md app_bluetooth.c app_cli.c app_init.c app_init.h app_process.c app_process.h connect_create_gbl_image.bat connect_create_gbl_image.sh main.c README.md
  group Simplicity Configurator/autogen
    autogen/: AGENTS-SLAB.md app_framework_event_table.c callback_dispatcher.c callback_dispatcher.h gatt_db.c gatt_db.h gen.properties linkerfile.icf radioconf_generation_log.json rail_config.c rail_config.h RTE_Components.h sl_application_type.h sl_bluetooth.c sl_bluetooth.h sl_cli_command_table.c sl_cli_command_table.html sl_cli_handles.h sl_cli_instances.c sl_cli_instances.h sl_component_catalog.h sl_event_handler.c sl_event_handler.h sl_iostream_handles.c sl_iostream_handles.h sl_iostream_init_eusart_instances.c sl_iostream_init_eusart_instances.h sl_iostream_init_instances.h sl_simple_led_instances.c sl_simple_led_instances.h sli_cli_hooks.c sli_mbedtls_config_autogen.h sli_mbedtls_config_transform_autogen.h sli_psa_builtin_config_autogen.h sli_psa_config_autogen.h
  group Simplicity Configurator/autogen/.slc_state
    autogen/.slc_state/: .crc_config.crc apack_radioconfig.crc
  group Simplicity Configurator/config
    config/: app_assert_config.h app_log_config.h app_properties_config.h btl_interface_cfg.h cmsis-rtos-ipc-config.h debug_print_config.h dmadrv_config.h FreeRTOSConfig.h frequency-hopping-config.h mac-queue-config.h nvm3_default_config.h parent-support-config.h poll-config.h psa_crypto_config.h sl_bgapi_config.h sl_bluetooth_advertiser_config.h sl_bluetooth_config.h sl_bluetooth_connection_config.h sl_bt_host_adaptation_config.h sl_bt_rtos_config.h sl_bt_rtos_config_s2.h sl_btctrl_config.h sl_btctrl_scheduler_priority_config.h sl_cli_config.h sl_cli_config_example.h sl_clock_manager_oscillator_config.h sl_clock_manager_tree_config.h sl_core_config.h sl_custom_manufacturing_token_header.h sl_custom_token_header.h sl_device_init_dcdc_config.h sl_hfxo_manager_config.h sl_iostream_eusart_inst0_config.h sl_main_start_task_config.h sl_mbedtls_config.h sl_mbedtls_device_config.h sl_memory_manager_config.h sl_memory_manager_region_config.h sl_power_manager_config.h sl_rail_util_pa_config.h sl_rail_util_pa_tables_config.h sl_rail_util_power_manager_init_config.h sl_rail_util_pti_config.h sl_simple_led_led0_config.h sl_sleeptimer_config.h sl_token_manager_config.h stack-common-config.h
  group Simplicity Configurator/config/btconf
    config/btconf/: gatt_configuration.btconf
  group Simplicity Configurator/config/rail
    config/rail/: profile_connect.restriction profile_long_range.restriction radio_settings.radioconf
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/bgapi_trace/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/bgapi_trace/release/: libbgapi_trace_stub.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/command/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/command/release/: libbgapi_command.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/core/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/core/release/: libbgapi_core.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/device/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/device/release/: libbgapi_device.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/event/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/event/release/: libbgapi_event.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/release
    simplicity_sdk_2025.12.3/bgapi_protocol/build/iar/cortex-m33/protocol/release/: libbgapi_protocol.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/protocol/inc
    simplicity_sdk_2025.12.3/bgapi_protocol/protocol/inc/: sl_bgapi.h sli_bgapi.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bgapi_protocol/rtos_adaptation/inc
    simplicity_sdk_2025.12.3/bgapi_protocol/rtos_adaptation/inc/: sli_bgapi_rtos_adaptation.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_apploader/inc
    simplicity_sdk_2025.12.3/bluetooth_apploader/inc/: sl_apploader_util.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_apploader/src
    simplicity_sdk_2025.12.3/bluetooth_apploader/src/: sl_apploader_util.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_common/inc
    simplicity_sdk_2025.12.3/bluetooth_common/inc/: sli_bgcommon_debug.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_common/lib/build/iar/cortex-m33/bgcommon/release
    simplicity_sdk_2025.12.3/bluetooth_common/lib/build/iar/cortex-m33/bgcommon/release/: libbgcommon.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_common/src
    simplicity_sdk_2025.12.3/bluetooth_common/src/: sli_bgcommon_debug_efr32.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_controller/build/iar/xg28/release
    simplicity_sdk_2025.12.3/bluetooth_le_controller/build/iar/xg28/release/: liblinklayer.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_controller/inc
    simplicity_sdk_2025.12.3/bluetooth_le_controller/inc/: sl_bt_ll_config.h sl_btctrl_callbacks.h sl_btctrl_linklayer.h sl_btctrl_linklayer_defs.h sl_btctrl_packets.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_controller/src
    simplicity_sdk_2025.12.3/bluetooth_le_controller/src/: sl_btctrl_init.c sl_btctrl_init_tasklets.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/api
    simplicity_sdk_2025.12.3/bluetooth_le_host/api/: sl_bt.xapi
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/accept_list/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/accept_list/release/: libble_host_accept_list_stub.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/bgstack/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/bgstack/release/: libble_host.a libbondingdb.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/ble_bgapi/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/ble_bgapi/release/: libble_bgapi.a libble_bgapi_gatt_client.a libble_bgapi_gatt_server.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/ble_system/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/ble_system/release/: libble_system.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/connection_subrating/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/connection_subrating/release/: libble_host_connection_subrating_stub.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/core/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/core/release/: libble_host_core.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/hal/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/hal/release/: libble_host_hal_series2.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/hci/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/hci/release/: libble_host_hci.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/system/release
    simplicity_sdk_2025.12.3/bluetooth_le_host/build/iar/cortex-m33/system/release/: libble_host_system.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/inc
    simplicity_sdk_2025.12.3/bluetooth_le_host/inc/: sl_bt_api.h sl_bt_api_compatibility.h sl_bt_ll_config.h sl_bt_rtos_adaptation.h sl_bt_stack_config.h sl_bt_stack_init.h sl_bt_types.h sl_bt_version.h sli_bt_accept_list_config.h sli_bt_advertiser_config.h sli_bt_api.h sli_bt_config_defs.h sli_bt_connection_config.h sli_bt_dynamic_gattdb_config.h sli_bt_external_bondingdb_config.h sli_bt_gattdb_def.h sli_bt_hci_event_table.h sli_bt_host_adaptation.h sli_bt_l2cap_config.h sli_bt_pawr_advertiser_config.h sli_bt_periodic_advertiser_config.h sli_bt_sync_config.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bluetooth_le_host/src
    simplicity_sdk_2025.12.3/bluetooth_le_host/src/: sl_bt_rtos_adaptation.c sl_bt_stack_init.c sli_bt_accept_list_config.c sli_bt_advertiser_config.c sli_bt_connection_config.c sli_bt_dynamic_gattdb_config.c sli_bt_external_bondingdb_config.c sli_bt_hci_event_table.c sli_bt_host_adaptation.c sli_bt_l2cap_config.c sli_bt_pawr_advertiser_config.c sli_bt_periodic_advertiser_config.c sli_bt_sync_config.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/api
    simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/api/: application_properties.h btl_errorcode.h btl_interface.c btl_interface.h btl_interface_parser.h btl_interface_storage.c btl_interface_storage.h btl_reset_info.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/app_properties
    simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/app_properties/: app_properties.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/core
    simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/core/: btl_util.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/core/flash
    simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/core/flash/: btl_internal_flash.c btl_internal_flash.h btl_internal_flash_raw.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/storage/internal_flash
    simplicity_sdk_2025.12.3/bootloader_interface/platform/bootloader/storage/internal_flash/: btl_storage_internal_flash_raw.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/cmsis/Core/Include
    simplicity_sdk_2025.12.3/cmsis/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/cmsis/RTOS2/Include
    simplicity_sdk_2025.12.3/cmsis/RTOS2/Include/: cmsis_os2.h os_tick.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/cmsis/RTOS2/Source
    simplicity_sdk_2025.12.3/cmsis/RTOS2/Source/: os_systick.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/cmsis_common/platform/common/inc
    simplicity_sdk_2025.12.3/cmsis_common/platform/common/inc/: sl_cmsis_os2_common.h sli_cmsis_os2_ext_task_register.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/cmsis_common/platform/common/src
    simplicity_sdk_2025.12.3/cmsis_common/platform/common/src/: sl_cmsis_os2_common.c sli_cmsis_os2_ext_task_register.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/common_15_4/util/silicon_labs/silabs_core/buffer_manager
    simplicity_sdk_2025.12.3/common_15_4/util/silicon_labs/silabs_core/buffer_manager/: buffer-management.c buffer-management.h buffer-queue.c buffer-queue.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_sdk/component/sl_light_switch
    simplicity_sdk_2025.12.3/connect_sdk/component/sl_light_switch/: sl_light_switch.c sl_light_switch.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/app-framework-common
    simplicity_sdk_2025.12.3/connect_stack/app-framework-common/: app_framework_callback.h app_framework_common.c app_framework_common.h app_framework_common_cb.c app_framework_sleep.c app_framework_stack_cb.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/ble-cli
    simplicity_sdk_2025.12.3/connect_stack/ble-cli/: ble-cli.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/cmsis-stack-ipc
    simplicity_sdk_2025.12.3/connect_stack/cmsis-stack-ipc/: cmsis-rtos-af-task.c cmsis-rtos-ipc-common.c cmsis-rtos-support-gen.h cmsis-rtos-support.c cmsis-rtos-support.h cmsis-rtos-vncp-task.c os_app_hooks.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/csp
    simplicity_sdk_2025.12.3/connect_stack/csp/: csp-api-enum-gen.h csp-command-app.c csp-command-callbacks-app.c csp-command-callbacks-vncp.c csp-command-utils.h csp-command-vncp.c csp-format.c csp-format.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/debug-print
    simplicity_sdk_2025.12.3/connect_stack/debug-print/: debug_print.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/libs
    simplicity_sdk_2025.12.3/connect_stack/libs/: libconnect-frequency-hopping-library-efr32xg2x-iar.a libconnect-packet-queue-library-efr32xg2x-iar.a libconnect-parent-support-library-efr32xg2x-iar.a libconnect-psa-security-library-efr32xg2x-iar.a libconnect-stack-common-library-efr32xg2x-iar.a libconnect-stack-counters-library-efr32xg2x-iar.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/ncp
    simplicity_sdk_2025.12.3/connect_stack/ncp/: ncp-security.h ncp-stubs.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/poll
    simplicity_sdk_2025.12.3/connect_stack/poll/: poll.c poll.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/stack/config
    simplicity_sdk_2025.12.3/connect_stack/stack/config/: config.h ember-configuration-defaults.h ember-configuration.c ember-configuration.h sl_connect_radio_priority_config.h stack-callback-stubs.c stack-stubs.c token-stack.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/stack/core
    simplicity_sdk_2025.12.3/connect_stack/stack/core/: sl-connect-assert.h sl-connect-rail-assert.c sl-connect-watchdog.c sl-connect-watchdog.h sli-connect-api.h sli-connect-interrupt-manipulation.h sli-connect-token.c sli-connect-token.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/stack/framework
    simplicity_sdk_2025.12.3/connect_stack/stack/framework/: sl-connect-info.c sl-connect-power-manager.c sl-connect-power-manager.h sli-connect-random.c sli-connect-random.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/connect_stack/stack/include
    simplicity_sdk_2025.12.3/connect_stack/stack/include/: byte-utilities.h ember-types.h ember.h error-def.h error.h event.h memory-buffer.h message.h network-management.h packet-buffer.h platform-header.h radio-stream.h stack-info.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/devices/platform/Device/SiliconLabs/EFR32FG28/Include
    simplicity_sdk_2025.12.3/devices/platform/Device/SiliconLabs/EFR32FG28/Include/: efr32fg28_acmp.h efr32fg28_aes.h efr32fg28_buram.h efr32fg28_burtc.h efr32fg28_cmu.h efr32fg28_dcdc.h efr32fg28_devinfo.h efr32fg28_dma_descriptor.h efr32fg28_dpll.h efr32fg28_emu.h efr32fg28_eusart.h efr32fg28_fsrco.h efr32fg28_gpcrc.h efr32fg28_gpio.h efr32fg28_gpio_port.h efr32fg28_hfrco.h efr32fg28_hfxo.h efr32fg28_i2c.h efr32fg28_iadc.h efr32fg28_icache.h efr32fg28_keyscan.h efr32fg28_lcd.h efr32fg28_lcdrf.h efr32fg28_ldma.h efr32fg28_ldmaxbar.h efr32fg28_ldmaxbar_defines.h efr32fg28_lesense.h efr32fg28_letimer.h efr32fg28_lfrco.h efr32fg28_lfxo.h efr32fg28_mailbox.h efr32fg28_mpahbram.h efr32fg28_msc.h efr32fg28_mvp.h efr32fg28_pcnt.h efr32fg28_pfmxpprf.h efr32fg28_prs.h efr32fg28_prs_signals.h efr32fg28_scratchpad.h efr32fg28_semailbox.h efr32fg28_smu.h efr32fg28_syscfg.h efr32fg28_sysrtc.h efr32fg28_timer.h efr32fg28_ulfrco.h efr32fg28_usart.h efr32fg28_vdac.h efr32fg28_wdog.h efr32fg28b322f1024im68.h em_device.h system_efr32fg28.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/devices/platform/Device/SiliconLabs/EFR32FG28/Source
    simplicity_sdk_2025.12.3/devices/platform/Device/SiliconLabs/EFR32FG28/Source/: startup_efr32fg28.c system_efr32fg28.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/cmsis/Include
    simplicity_sdk_2025.12.3/freertos/cmsis/Include/: freertos_mpool.h freertos_os2.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/cmsis/Source
    simplicity_sdk_2025.12.3/freertos/cmsis/Source/: cmsis_os2.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/kernel
    simplicity_sdk_2025.12.3/freertos/kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/kernel/include
    simplicity_sdk_2025.12.3/freertos/kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    simplicity_sdk_2025.12.3/freertos/kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/kernel/portable/MemMang
    simplicity_sdk_2025.12.3/freertos/kernel/portable/MemMang/: heap_3.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/freertos/kernel/portable/SiliconLabs/cortexm
    simplicity_sdk_2025.12.3/freertos/kernel/portable/SiliconLabs/cortexm/: tick_power_manager.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_common/platform/common/inc
    simplicity_sdk_2025.12.3/platform_common/platform/common/inc/: sl_assert.h sl_atomic.h sl_bit.h sl_code_classification.h sl_common.h sl_compiler.h sl_enum.h sl_slist.h sl_status.h sl_string.h sli_code_classification.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_common/platform/common/src
    simplicity_sdk_2025.12.3/platform_common/platform/common/src/: sl_assert.c sl_slist.c sl_string.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_common_apps/app/common/util/app_assert
    simplicity_sdk_2025.12.3/platform_common_apps/app/common/util/app_assert/: app_assert.h sl_app_assert.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_common_apps/app/common/util/app_log
    simplicity_sdk_2025.12.3/platform_common_apps/app/common/util/app_log/: app_log.c app_log.h sl_app_log.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/common/errno_error_codes/inc
    simplicity_sdk_2025.12.3/platform_core/platform/common/errno_error_codes/inc/: errno_error_codes.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/common/inc
    simplicity_sdk_2025.12.3/platform_core/platform/common/inc/: sl_core.h sl_platform_version.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/common/src
    simplicity_sdk_2025.12.3/platform_core/platform/common/src/: sl_core_cortexm.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/driver/gpio/inc
    simplicity_sdk_2025.12.3/platform_core/platform/driver/gpio/inc/: sl_gpio.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/driver/gpio/src
    simplicity_sdk_2025.12.3/platform_core/platform/driver/gpio/src/: sl_gpio.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/driver/leddrv/inc
    simplicity_sdk_2025.12.3/platform_core/platform/driver/leddrv/inc/: sl_led.h sl_simple_led.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/driver/leddrv/src
    simplicity_sdk_2025.12.3/platform_core/platform/driver/leddrv/src/: sl_led.c sl_simple_led.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/common/inc
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/inc
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/inc/: dmadrv.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/inc/s2_signals
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/inc/s2_signals/: dmadrv_signals.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/src
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/dmadrv/src/: dmadrv.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/config
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/config/: nvm3_config.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/inc
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/inc/: nvm3.h nvm3_cache.h nvm3_default.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h nvm3_object.h nvm3_page.h nvm3_trace.h nvm3_utils.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/src
    simplicity_sdk_2025.12.3/platform_core/platform/emdrv/nvm3/src/: nvm3.c nvm3_cache.c nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c nvm3_object.c nvm3_page.c nvm3_utils.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emlib/inc
    simplicity_sdk_2025.12.3/platform_core/platform/emlib/inc/: em_assert.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_core_generic.h em_emu.h em_eusart.h em_eusart_compat.h em_gpio.h em_ldma.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_rmu.h em_syscfg.h em_system.h em_system_generic.h em_timer.h em_version.h em_wdog.h sli_em_cmu.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/emlib/src
    simplicity_sdk_2025.12.3/platform_core/platform/emlib/src/: em_burtc.c em_cmu.c em_emu.c em_eusart.c em_gpio.c em_ldma.c em_msc.c em_prs.c em_rmu.c em_system.c em_timer.c em_wdog.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/peripheral/inc
    simplicity_sdk_2025.12.3/platform_core/platform/peripheral/inc/: peripheral_sysrtc.h peripheral_sysrtc_compat.h sl_hal_bus.h sl_hal_eusart.h sl_hal_gpio.h sl_hal_prs.h sl_hal_prs_enums.h sl_hal_syscfg.h sl_hal_sysrtc.h sl_hal_sysrtc_compat.h sl_hal_sysrtc_subsystem.h sl_hal_system.h sl_hal_system_generic.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/peripheral/src
    simplicity_sdk_2025.12.3/platform_core/platform/peripheral/src/: sl_hal_eusart.c sl_hal_gpio.c sl_hal_prs.c sl_hal_syscfg.c sl_hal_sysrtc.c sl_hal_sysrtc_subsystem.c sl_hal_system.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/cli/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/cli/inc/: sl_cli.h sl_cli_arguments.h sl_cli_command.h sl_cli_input.h sl_cli_tokenize.h sl_cli_types.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/cli/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/cli/src/: sl_cli.c sl_cli_arguments.c sl_cli_command.c sl_cli_input.c sl_cli_io.c sl_cli_tokenize.c sli_cli_arguments.h sli_cli_input.h sli_cli_io.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/clock_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/clock_manager/inc/: sl_clock_manager.h sl_clock_manager_init.h sli_clock_manager.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/clock_manager/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/clock_manager/src/: sl_clock_manager.c sl_clock_manager_hal_s2.c sl_clock_manager_init.c sl_clock_manager_init_hal_s2.c sli_clock_manager_hal.h sli_clock_manager_init_hal.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_init/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_init/inc/: sl_device_init_dcdc.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_init/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_init/src/: sl_device_init_dcdc_s2.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/clocks
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/clocks/: sl_device_clock_efr32xg28.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/devices
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/devices/: sl_device_peripheral_hal_efr32xg28.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/dma
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/dma/: sl_device_dma_s2.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/inc/: sl_device_clock.h sl_device_dma.h sl_device_gpio.h sl_device_i2c.h sl_device_peripheral.h sl_device_peripheral_types.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/device_manager/src/: sl_device_clock.c sl_device_dma.c sl_device_gpio.c sl_device_peripheral.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/hfxo_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/hfxo_manager/inc/: sl_hfxo_manager.h sli_hfxo_manager.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/hfxo_manager/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/hfxo_manager/src/: sl_hfxo_manager.c sl_hfxo_manager_hal_s2.c sli_hfxo_manager_internal.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/inc/: sl_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/inc/arm
    simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/inc/arm/: cmsis_nvic_virtual.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/interrupt_manager/src/: sl_interrupt_manager_cortexm.c sli_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/iostream/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/iostream/inc/: sl_iostream.h sl_iostream_eusart.h sl_iostream_stdlib_config.h sl_iostream_uart.h sli_iostream.h sli_iostream_uart.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/iostream/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/iostream/src/: sl_iostream.c sl_iostream_eusart.c sl_iostream_retarget_stdio.c sl_iostream_stdlib_config.c sl_iostream_uart.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/inc/: sl_memory_manager.h sl_memory_manager_region.h sli_memory_manager_retention_control.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/profiler/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/profiler/inc/: sli_memory_profiler.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/profiler/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/profiler/src/: sli_memory_profiler_stubs.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/memory_manager/src/: sl_memory_manager.c sl_memory_manager_dynamic_reservation.c sl_memory_manager_pool.c sl_memory_manager_pool_common.c sl_memory_manager_region.c sl_memory_manager_retarget.c sli_memory_manager.h sli_memory_manager_common.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/mpu/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/mpu/inc/: sl_mpu.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/mpu/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/mpu/src/: sl_mpu_s2.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/inc/: sl_power_manager.h sl_power_manager_debug.h sli_power_manager.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/src/common
    simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/src/common/: sl_power_manager_common.c sl_power_manager_em4.c sli_power_manager_common_private.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/src/sleep_loop
    simplicity_sdk_2025.12.3/platform_core/platform/service/power_manager/src/sleep_loop/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s2.c sli_power_manager_private.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/inc/: sl_main_init.h sl_main_init_memory.h sl_main_kernel.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/src/: sl_main_init.c sl_main_init_memory.c sl_main_kernel.c sli_main_init_memory.h sli_main_kernel.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/src/rtos
    simplicity_sdk_2025.12.3/platform_core/platform/service/sl_main/src/rtos/: main_retarget.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/sleeptimer/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/sleeptimer/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_burtc.c sl_sleeptimer_hal_sysrtc.c sl_sleeptimer_hal_timer.c sli_sleeptimer_hal.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/token_manager/legacy/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/token_manager/legacy/inc/: sl_token_api.h sl_token_manager.h sl_token_manager_af_token_header.h sl_token_manufacturing.h sl_token_manufacturing_api.h sl_token_manufacturing_generic.h sl_token_manufacturing_series_2.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/token_manager/legacy/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/token_manager/legacy/src/: sl_token_def.c sl_token_manager.c sl_token_manufacturing.c sl_token_manufacturing_generic.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/udelay/inc
    simplicity_sdk_2025.12.3/platform_core/platform/service/udelay/inc/: sl_udelay.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/platform_core/platform/service/udelay/src
    simplicity_sdk_2025.12.3/platform_core/platform/service/udelay/src/: sl_udelay.c sl_udelay_armv6m_iar.s
  group Simplicity Configurator/simplicity_sdk_2025.12.3/printf
    simplicity_sdk_2025.12.3/printf/: printf.c printf.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/printf/inc
    simplicity_sdk_2025.12.3/printf/inc/: iostream_printf.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/printf/src
    simplicity_sdk_2025.12.3/printf/src/: iostream_printf.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/autogen/librail_release
    simplicity_sdk_2025.12.3/rail_library/autogen/librail_release/: librail_multiprotocol_efr32xg28_iar_release.a
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/chip/efr32/efr32xg2x
    simplicity_sdk_2025.12.3/rail_library/chip/efr32/efr32xg2x/: rail_chip_specific.h sl_rail_chip_specific.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/common
    simplicity_sdk_2025.12.3/rail_library/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h sl_rail.h sl_rail_assert_error_codes.h sl_rail_features.h sl_rail_mfm.h sl_rail_types.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_compatible_pa
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_compatible_pa/: sl_rail_util_compatible_pa.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_conversions
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_conversions/: sl_rail_util_pa_conversions.c sl_rail_util_pa_conversions.h sl_rail_util_pa_tables.c sl_rail_util_pa_types.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_tables
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_tables/: sl_rail_util_pa_tables.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_tables/efr32xg28
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pa_tables/efr32xg28/: sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_868M_HP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_868M_LLP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_868M_LP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_868M_MP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_915M_HP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_915M_LLP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_915M_LP.h sl_rail_util_pa_dbm_powersetting_mapping_table_14dbm_915M_MP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_868M_HP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_868M_LLP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_868M_LP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_868M_MP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_915M_HP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_915M_LLP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_915M_LP.h sl_rail_util_pa_dbm_powersetting_mapping_table_20dbm_915M_MP.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_power_manager_init
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_power_manager_init/: sl_rail_util_power_manager_init.c sl_rail_util_power_manager_init.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pti
    simplicity_sdk_2025.12.3/rail_library/plugin/sl_rail_util_pti/: sl_rail_util_pti.c sl_rail_util_pti.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/protocol/ble
    simplicity_sdk_2025.12.3/rail_library/protocol/ble/: rail_ble.h sl_rail_ble.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/protocol/ieee802154
    simplicity_sdk_2025.12.3/rail_library/protocol/ieee802154/: rail_ieee802154.h sl_rail_ieee802154.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/protocol/sidewalk
    simplicity_sdk_2025.12.3/rail_library/protocol/sidewalk/: rail_sidewalk.h sl_rail_sidewalk.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/protocol/wmbus
    simplicity_sdk_2025.12.3/rail_library/protocol/wmbus/: rail_wmbus.h sl_rail_wmbus.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/rail_library/protocol/zwave
    simplicity_sdk_2025.12.3/rail_library/protocol/zwave/: rail_zwave.h sl_rail_zwave.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/config
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/config/: sli_mbedtls_acceleration.h sli_mbedtls_omnipresent.h sli_psa_acceleration.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/inc
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/inc/: aes_alt.h ccm_alt.h cmac_alt.h ecjpake_alt.h gcm_alt.h se_management.h sha1_alt.h sha256_alt.h sha512_alt.h sl_mbedtls.h sl_psa_crypto.h sl_psa_values.h sli_psa_crypto.h threading_alt.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/src
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_mbedtls_support/src/: mbedtls_ccm.c se_aes.c sl_mbedtls.c sl_psa_crypto.c sli_psa_crypto.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_protocol_crypto/src
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_protocol_crypto/src/: sli_protocol_crypto.h sli_protocol_crypto_radioaes.c sli_radioaes_management.c sli_radioaes_management.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/inc
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/inc/: sli_psa_driver_common.h sli_psa_driver_features.h sli_se_driver_aead.h sli_se_driver_cipher.h sli_se_driver_key_derivation.h sli_se_driver_key_management.h sli_se_driver_mac.h sli_se_opaque_functions.h sli_se_opaque_types.h sli_se_transparent_functions.h sli_se_transparent_types.h sli_se_version_dependencies.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/inc/psa
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/inc/psa/: error.h internal_trusted_storage.h sli_internal_trusted_storage.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/src
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sl_psa_driver/src/: sl_psa_its_nvm3.c sli_psa_driver_common.c sli_psa_driver_init.c sli_psa_trng.c sli_se_driver_aead.c sli_se_driver_builtin_keys.c sli_se_driver_cipher.c sli_se_driver_key_derivation.c sli_se_driver_key_management.c sli_se_driver_mac.c sli_se_driver_signature.c sli_se_opaque_driver_aead.c sli_se_opaque_driver_cipher.c sli_se_opaque_driver_mac.c sli_se_opaque_key_derivation.c sli_se_transparent_driver_aead.c sli_se_transparent_driver_cipher.c sli_se_transparent_driver_hash.c sli_se_transparent_driver_mac.c sli_se_transparent_key_derivation.c sli_se_version_dependencies.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sli_crypto/inc
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sli_crypto/inc/: sli_crypto.h sli_crypto_s2.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sli_crypto/src
    simplicity_sdk_2025.12.3/security_mbedtls/platform/security/sl_component/sli_crypto/src/: sl_crypto_s2.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls_source/include/mbedtls
    simplicity_sdk_2025.12.3/security_mbedtls_source/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls_source/include/psa
    simplicity_sdk_2025.12.3/security_mbedtls_source/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_mbedtls_source/library
    simplicity_sdk_2025.12.3/security_mbedtls_source/library/: aes.c alignment.h base64_internal.h bignum_core.h bignum_core_invasive.h bignum_internal.h bignum_mod.h bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h ccm.c check_crypto_config.h cipher.c cipher_invasive.h cipher_wrap.c cipher_wrap.h common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr.h debug_internal.h ecp_internal_alt.h ecp_invasive.h entropy_poll.h lmots.h md_psa.h md_wrap.h mps_common.h mps_error.h mps_reader.h mps_trace.h padlock.h pk_internal.h pk_wrap.h pkwrite.h platform.c platform_util.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_util.c psa_util_internal.h rsa_alt_helpers.h rsa_internal.h ssl_ciphersuites_internal.h ssl_client.h ssl_debug_helpers.h ssl_misc.h ssl_tls13_invasive.h ssl_tls13_keys.h threading.c x509_internal.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/se_manager/inc
    simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/se_manager/inc/: sl_se_manager.h sl_se_manager_attestation.h sl_se_manager_check_config.h sl_se_manager_cipher.h sl_se_manager_config.h sl_se_manager_defines.h sl_se_manager_entropy.h sl_se_manager_hash.h sl_se_manager_internal_keys.h sl_se_manager_key_derivation.h sl_se_manager_key_handling.h sl_se_manager_signature.h sl_se_manager_types.h sl_se_manager_util.h sli_se_manager_features.h sli_se_manager_internal.h sli_se_manager_mailbox.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/se_manager/src
    simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/se_manager/src/: sl_se_manager.c sl_se_manager_attestation.c sl_se_manager_cipher.c sl_se_manager_entropy.c sl_se_manager_hash.c sl_se_manager_key_derivation.c sl_se_manager_key_handling.c sl_se_manager_signature.c sl_se_manager_util.c sli_se_manager_mailbox.c
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/sli_psec_osal/inc
    simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/sli_psec_osal/inc/: sli_psec_osal.h sli_psec_osal_cmsis_rtos2.h
  group Simplicity Configurator/simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/sli_psec_osal/src
    simplicity_sdk_2025.12.3/security_se_manager/platform/security/sl_component/sli_psec_osal/src/: sli_psec_osal_cmsis_rtos2.c
